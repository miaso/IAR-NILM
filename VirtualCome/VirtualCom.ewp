# IAR project VirtualCom.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2478 NXP LPC2478
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 1
  General.FPU2: 0
  ICCARM.CCDefines: IAR_LPC_2478_STK
  ICCARM.CCIncludePath2: app; board; modules; uip; uip\httpd
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: virtual_com.out
  ILINK.IlinkIcfFile: config\LPC2478_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SDRAM Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR_LPC_2478_STK; SDRAM_DEBUG
  ICCARM.CCIncludePath2: app\; board\; modules\; 
  ILINK.IlinkIcfFile: config\LPC2478_SDRAM.icf
  group (top)
    app/: main.c
    ./: readme.txt
  group Modules
    app/: clock-arch.c
    modules/: drv_touch_scr.c irq.c LPC24xx_enet.c timer.c
    board/: sys.c
  group Modules/Fonts
    app/: Terminal_18_24x12.c Terminal_6_8x6.c Terminal_9_12x6.c
  group Modules/GLCD
    modules/: drv_glcd.c
  group Modules/Pictures
    app/: iar_logo.c
  group Modules/SDRAM
    modules/: sdram_64M_32bit_drv.c
  group Modules/UARTs
    app/: uart.c
  group uIP
    uip/: psock.c uip.c uip_arp.c
  group uIP/http
    uip/httpd/: http-strings.c httpd-cgi.c httpd-fs.c httpd.c
  group USB/Class
    app/: cd_class.c usb_dev_desc.c usb_hooks.c
  group USB/Config
    app/: usb_cnfg.h
  group USB/Core
    modules/: usb_buffer.c usb_t9.c
  group USB/HW
    modules/: usb_hw.c
